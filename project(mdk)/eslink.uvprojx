# Keil uVision project eslink.uvprojx, settings and files
target es_link_II (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK22FN128xxx10 NXP
  pack: Keil.Kinetis_K20_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00004000) IRAM2(0x1FFFE000,0x00002000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eslink.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK22FN128VLH10,CDC_ENDPOINT,HID_ENDPOINT
  c misc: --gnu --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\bsp;..\drivers;..\source;..\startup;..\utilities;..\CMSIS;..\common;..\app;..\app\cmsis-dap;..\app\es-isp;..\app\es-icd;..\app\swd;..\app\es-bootisp;..\app\settings;..\app\offline;..\gui;..\bsp;..\rtos;..\middleware\RL-USB\usb;..\middleware\RL-USB;..\middleware\RL-USB\usb\cls;..\RL_FlashFS\include;..\RL_FlashFS\Driver
  asm define: DEBUG
  asm include: CMSIS;board;drivers;source;startup;utilities
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\startup\MK22FN128xxx10_flash.scf
  link misc: --predefine="-DESLINK_BL"
  group bsp
    ../bsp/: board.c clock_config.c eeprom.c gpio.c key.c pin_mux.c spi_flash.c uart.c
  group source
    ../source/: mian.c main.h error.c RTX_Config.c SVC_Table.s tasks.h error.h eslink_debug.h eslink_addr.h spi_flash_fs.c
  group es-target
    ../target_chip/: es32_c_blob.c booisp_target.c
  group cmsis-dap
    ../app/cmsis-dap/: DAP.c JTAG_DP.c SW_DP.c SWO.c usbd_user_hid.c
    ../app/: DAP_config.h
  group es_link
    ../app/: eslink.c eslink.h eslink_config.h eslink_def.h eslink_io_config.h usbd_user_cls_icd.c
  group offline
    ../app/offline/: prj_file.c prj_file.h
  group es-isp
    ../app/es-isp/: ES_ISP.c ES_ISP.h isp_def.h isp_bit_ops.c
  group es-bootisp
    ../app/es-bootisp/: bootisp_prg_intf.c bootisp_prg_intf.h bootisp_target_config.h bootisp_target_flash.c bootisp_target_flash.h
  group swd-prg
    ../app/swd/: swd_pgr_intf.c swd_pgr_intf.h swd_flash_blob.h swd_flash_intf.h swd_target_config.h swd_target_flash.c swd_host.c swd_host.h swd_target_reset.c swd_target_reset.h
  group settings
    ../app/settings/: settings.c settings_rom_stub.c settings.h
  group gui
    ../gui/: menu.c fonts.c oled.c app_display.c
  group iap
    ../iap/: FlashDev.c FlashPrg.c fsl_flash.c fsl_flash.h flash_hal.c
  group common
    ../common/: circ_buf.c cortex_m.c es_common.c cortex_m.h es_common.h es_types.h es_list.h
  group CMSIS
    ../CMSIS/: system_MK22F12810.c system_MK22F12810.h MK22F12810_features.h MK22F12810.h fsl_device_registers.h core_cm4.h
  group drivers
    ../drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_i2c.c fsl_dspi.c fsl_ftm.c fsl_lpuart.c fsl_lpuart.h
  group startup
    ../startup/: startup_MK22F12810.s
  group rtos
    ../rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../rtos/cm3/: HAL_CM3.c
  group rl-flashfs
    ../RL_FlashFS/Lib/: FSN_CM3.lib
    ../RL_FlashFS/Config/: File_Config.c Retarget.c
    ../RL_FlashFS/Driver/: FS_SPI_FlashDev.h FS_SPI_FlashPrg.c SPI_MK22FN.c
    ../RL_FlashFS/include/: absacc.h
  group usb_driver
    ../middleware/RL-USB/: usb_buf.h usb_config.c usbd_MK20D5.c
  group usb
    ../middleware/RL-USB/usb/: usbd_core.c usb_lib.c
    ../middleware/RL-USB/usb/cls/: usbd_cls.c usbd_core_cls.c
    ../middleware/RL-USB/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../middleware/RL-USB/usb/hid/: usbd_core_hid.c usbd_hid.c
  group doc
    ../doc/: 说明.txt 开发环境说明.txt
    ../doc/demo/: test.c
