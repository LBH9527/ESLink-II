# Keil uVision project eslink_08.uvprojx, settings and files
target es_link_II (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK22FN128VLH10 NXP
  pack: NXP.MK22F12810_DFP.10.0.0
  cpu: IRAM(0x1fffe000,0x2000) IRAM2(0x20000000,0x4000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: .\CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG,CPU_MK22FN128VLH10,CDC_ENDPOINT,HID_ENDPOINT,HR_8BIT
  c misc: --gnu --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\..\bsp;..\..\..\drivers;..\..\..\startup;..\..\..\utilities;..\..\..\CMSIS;..\..\..\common;..\..\..\gui;..\..\..\middleware\RL-USB\usb;..\..\..\middleware\RL-USB;..\..\..\middleware\RL-USB\usb\cls;..\..\..\iap;..\..\..\middleware\FatFS\src;..\source;..\source\es-debug;..\source\es-isp;..\source\offline;..\source\target_chip;..\..\..\eslink;..\..\..\eslink\offline
  asm define: DEBUG,OFL_VERSION=0x00000000,
  asm include: CMSIS;board;drivers;source;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: ..\startup\MK22FN128xxx10_flash.scf
  link misc: --predefine="-I..\..\..\eslink"
  group eslink
    ../../../eslink/: eslink.c errno.h eslink_config.h es_burner.c es_debug.c eslink_app_addr.h sflash_port.c eeprom_port.c usbd_user_cls.c
  group source
    ../source/: main.c main.h
  group bsp
    ../../../bsp/: eslink_gpio.h board.c gpio.c pin_mux.c clock_config.c eeprom.c key.c spi_flash.c uart.c systick.c beep.c
  group es-target
    ../source/target_chip/: target_program_config.c
  group offline
    ../../../eslink/offline/: offline_file.c offline_app.c offline_def.h
  group es-isp
    ../source/es-isp/: isp_prog_intf.h M620_ISP.c isp_prog_intf.c
  group es-debug
    ../source/es-debug/: hr7p169b_icd.c hr7p169b_icd.h
  group gui
    ../../../gui/: fonts.c oled.c link_menu.c message.c
  group iap
    ../../../iap/: update.c iap_flash_intf.c settings_rom.c
  group common
    ../../../common/: circ_buf.c circ_buf.h cortex_m.c cortex_m.h es_common.c es_common.h es_list.h es_types.h ustdlib.c
  group CMSIS
    ../../../CMSIS/: system_MK22F12810.c system_MK22F12810.h MK22F12810.h MK22F12810_features.h fsl_device_registers.h core_cm4.h
  group drivers
    ../../../drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_smc.c fsl_uart.c fsl_dspi.c fsl_flash.c
  group startup
    ../startup/: startup_MK22F12810.s
  group fatfs
    ../../../middleware/FatFS/src/: ff.c diskio.c ffconf.h
    ../../../middleware/FatFS/src/option/: unicode.c
  group usb_driver
    ../../../middleware/RL-USB/: usb_config.c usbd_MK20D5.c usb_buf.h
  group usb
    ../../../middleware/RL-USB/usb/: usb_lib.c usbd_core.c
    ../../../middleware/RL-USB/usb/hid/: usbd_core_hid.c usbd_hid.c
    ../../../middleware/RL-USB/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../middleware/RL-USB/usb/cls/: usbd_cls.c usbd_core_cls.c
  group usb2uart
    ../../../eslink/usb2uart/: usbd_user_cdc_acm.c
  group doc
    ../doc/: 说明.txt 开发环境说明.txt
