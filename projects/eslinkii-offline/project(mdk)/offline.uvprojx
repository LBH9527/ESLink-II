# Keil uVision project offline.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK22FN128VLH10 NXP
  pack: NXP.MK22F12810_DFP.10.0.3
  cpu: IRAM(0x1fffe000,0x2000) IRAM2(0x20000000,0x4000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eslink_offline +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK22FN128VLH10,NDEBUG
  c misc: --gnu --library_interface=armcc  --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\source;..\..\..\common;..\..\..\bsp;..\..\..\drivers;..\..\..\CMSIS;..\..\..\bsp;..\..\..\app;..\..\..\gui;..\..\..\middleware\ff13b\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: ..\source\MK22FN128xxx10_flash.scf
  link misc: --predefine="-I..\..\..\app"
  group eslink
    ../../../app/: eslink_addr.h
  group bsp
    ../../../bsp/: board.c clock_config.c gpio.c key.c pin_mux.c spi_flash.c uart.c systick.c
  group source
    ../source/: main.c main.h spi_flash_fs.c
  group gui
    ../../../gui/: fonts.c menu.c oled.c
  group common
    ../../../common/: circ_buf.c circ_buf.h cortex_m.c cortex_m.h es_common.c es_common.h es_list.h es_types.h
  group cmsis
    ../../../CMSIS/: system_MK22F12810.c system_MK22F12810.h MK22F12810.h MK22F12810_features.h fsl_device_registers.h core_cm4.h
  group drivers
    ../../../drivers/: fsl_clock.c fsl_gpio.c fsl_uart.c fsl_i2c.c fsl_dspi.c fsl_smc.c fsl_flash.c
  group starup
    ../../../startup/: startup_MK22F12810.s
  group fatfs
    ../../../middleware/ff13b/source/: ff.c diskio.c ffconf.h
