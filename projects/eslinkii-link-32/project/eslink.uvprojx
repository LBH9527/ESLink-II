# Keil uVision project eslink.uvprojx, settings and files
target es_link_II (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK22FN128VLH10 NXP
  pack: NXP.MK22F12810_DFP.10.0.0
  cpu: IRAM(0x1fffe000,0x2000) IRAM2(0x20000000,0x4000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: .\CopyHex_Flash.bat
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG,CPU_MK22FN128VLH10,CDC_ENDPOINT,HID_ENDPOINT,ES_32BIT,
  c misc: --gnu --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\..\bsp;..\..\..\drivers;..\..\..\startup;..\..\..\utilities;..\..\..\CMSIS;..\..\..\common;..\..\..\gui;..\..\..\middleware\RL-USB\usb;..\..\..\middleware\RL-USB;..\..\..\middleware\RL-USB\usb\cls;..\..\..\middleware\RL_FlashFS\include;..\..\..\middleware\RL_FlashFS\Driver;..\..\..\iap;..\..\..\middleware\FatFS\src;..\source;..\source\cmsis-dap;..\source\es-uartboot;..\source\es-debug;..\source\es-isp;..\source\swd;..\..\..\eslink;..\..\..\eslink\usb2uart;..\..\..\eslink\offline;..\source\offline;..\source\es-rtc;..\source\es-isp\M939_ISP
  asm define: DEBUG,
  asm include: CMSIS;board;drivers;source;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: ..\startup\MK22FN128xxx10_flash.scf
  link misc: --predefine="-I..\..\..\eslink"
  group eslink
    ../../../eslink/: eslink.c errno.h eslink_config.h eslink_debug.h es_burner.c eslink_app_addr.h eeprom_port.c sflash_port.c usbd_user_cls.c
  group bsp
    ../../../bsp/: eslink_gpio.h board.c gpio.c pin_mux.c clock_config.c eeprom.c key.c spi_flash.c uart.c systick.c beep.c adc.c
  group source
    ../source/: main.c main.h target_program_config.c target_program_config.h
  group offline
    ../../../eslink/offline/: offline_app.c offline_file.c offline_def.h
  group cmsis-dap
    ../source/cmsis-dap/: DAP.c JTAG_DP.c SW_DP.c SWO.c usbd_user_hid.c
  group es-isp
    ../source/es-isp/M610_ISP/: M610_ISP.c isp_prog_intf.c es_isp.h
  group es-uartboot
    ../source/es-uartboot/M939_UARTBOOT/: uartboot_prog_intf.c uartboot_host.c
  group es-rtc
    ../source/es-rtc/: rtc_calibrate.c
  group es-swd
    ../source/swd/M939_SWD/: swd_prog_intf.c swd_target_reset.c swd_target_info.c
    ../source/swd/: swd_host.c
  group gui
    ../../../gui/: fonts.c oled.c link_menu.c message.c
  group iap
    ../../../iap/: update.c iap_flash_intf.c settings_rom.c
  group common
    ../../../common/: circ_buf.c circ_buf.h cortex_m.c cortex_m.h es_common.c es_common.h es_list.h es_types.h
  group CMSIS
    ../../../CMSIS/: system_MK22F12810.c system_MK22F12810.h MK22F12810.h MK22F12810_features.h fsl_device_registers.h core_cm4.h
  group drivers
    ../../../drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_smc.c fsl_uart.c fsl_dspi.c fsl_flash.c fsl_ftm.c fsl_ftm.h fsl_adc16.c fsl_adc16.h fsl_cmp.c fsl_cmp.h fsl_pdb.c
  group startup
    ../startup/: startup_MK22F12810.s
  group fatfs
    ../../../middleware/FatFS/src/: ff.c diskio.c ffconf.h
    ../../../middleware/FatFS/src/option/: unicode.c
  group usb_driver
    ../../../middleware/RL-USB/: usb_config.c usbd_MK20D5.c usb_buf.h
  group usb
    ../../../middleware/RL-USB/usb/: usb_lib.c usbd_core.c
    ../../../middleware/RL-USB/usb/hid/: usbd_core_hid.c usbd_hid.c
    ../../../middleware/RL-USB/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../middleware/RL-USB/usb/cls/: usbd_cls.c
  group usb2uart
    ../../../eslink/usb2uart/: usbd_user_cdc_acm.c
  group doc
    ../doc/: 说明.txt 开发环境说明.txt
