# Keil uVision project boot.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK22FN128VLH10 NXP
  pack: NXP.MK22F12810_DFP.10.0.0
  cpu: IRAM(0x1fffe000,0x2000) IRAM2(0x20000000,0x4000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eslink_boot +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK22FN128VLH10,NDEBUG,HID_ENDPOINT, CDC_ENDPOINT,HR_8BIT
  c misc: --gnu --library_interface=armcc  --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\source;..\..\..\common;..\..\..\bsp;..\..\..\drivers;..\..\..\CMSIS;..\..\..\app;..\..\..\bsp;..\..\..\app;..\..\..\iap;..\..\..\gui;..\..\..\app\es-debug;..\..\..\middleware\ff13b\source;..\..\..\middleware\RL-USB;..\..\..\middleware\RL-USB\usb;..\..\..\middleware\RL-USB\usb\cls;..\..\..\eslink;..\..\..\eslink\offline
  asm define: HARDWARE_VERSION=0x00000101,
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: ..\startup\MK22FN128xxx10_flash.scf
  link misc: --predefine="-I..\..\..\eslink"
  group eslink
    ../../../eslink/: usbd_user_cls_icd.c eslink.h eslink.c eslink_app_addr.h sflash_port.c
  group bsp
    ../../../bsp/: board.c clock_config.c gpio.c pin_mux.c spi_flash.c systick.c uart.c
  group source
    ../source/: main.c main.h eslink_boot.c debug_boot.c
  group iap
    ../../../iap/: iap_flash_intf.c iap_flash_intf.h update.c update.h settings_rom.c
  group common
    ../../../common/: circ_buf.c circ_buf.h cortex_m.c cortex_m.h es_common.c es_common.h es_list.h es_types.h
  group cmsis
    ../../../CMSIS/: system_MK22F12810.c system_MK22F12810.h MK22F12810.h MK22F12810_features.h fsl_device_registers.h core_cm4.h
  group drivers
    ../../../drivers/: fsl_clock.c fsl_gpio.c fsl_uart.c fsl_dspi.c fsl_smc.c fsl_flash.c fsl_flash.h
  group starup
    ../startup/: startup_MK22F12810.s
  group usb_driver
    ../../../middleware/RL-USB/: usbd_MK20D5.c usb_config.c
  group usb
    ../../../middleware/RL-USB/usb/: usbd_core.c
    ../../../middleware/RL-USB/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../middleware/RL-USB/usb/cls/: usbd_cls.c usbd_core_cls.c
    ../../../middleware/RL-USB/usb/hid/: usbd_core_hid.c usbd_hid.c
  group doc
    ../doc/: 说明.txt
