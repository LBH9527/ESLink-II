# Keil uVision project eslink.uvprojx, settings and files
target es_link_II (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK22FN128VLH10 NXP
  pack: NXP.MK22F12810_DFP.10.0.0
  cpu: IRAM(0x1fffe000,0x2000) IRAM2(0x20000000,0x4000) IROM(0x00000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: D:\DAPLink_Workspace\eslink\projects\eslinkii-link\project\CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG,CPU_MK22FN128VLH10,CDC_ENDPOINT,HID_ENDPOINT
  c misc: --gnu --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\..\bsp;..\..\..\drivers;..\source;..\..\..\startup;..\..\..\utilities;..\..\..\CMSIS;..\..\..\common;..\..\..\app;..\..\..\app\cmsis-dap;..\..\..\app\es-isp;..\..\..\app\es-icd;..\..\..\app\swd;..\..\..\app\es-bootisp;..\..\..\app\target_chip;..\..\..\app\offline;..\..\..\gui;..\..\..\rtos;..\..\..\middleware\RL-USB\usb;..\..\..\middleware\RL-USB;..\..\..\middleware\RL-USB\usb\cls;..\..\..\middleware\RL_FlashFS\include;..\..\..\middleware\RL_FlashFS\Driver;..\..\..\iap;..\..\..\middleware\FatFS\src
  asm define: DEBUG,OFL_VERSION=0x00000000,
  asm include: CMSIS;board;drivers;source;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\startup\MK22FN128xxx10_flash.scf
  link misc: --predefine="-I..\..\..\app"
  group eslink
    ../../../app/: usbd_user_cls_icd.c eslink.h eslink_config.h eslink_def.h eslink_addr.h errno.h settings_spi_flash.c
  group bsp
    ../../../bsp/: eslink_gpio.h board.c gpio.c pin_mux.c clock_config.c eeprom.c key.c spi_flash.c uart.c
  group source
    ../source/: main.c RTX_Config.c main.h tasks.h eslink_debug.h SVC_Table.s eslink_link.c
  group es-target
    ../../../app/target_chip/: es32_c_blob.c booisp_target.c es_target_set.c es_target_set.h
  group offline
    ../../../app/offline/: offline_app.c offline_file.c offline_def.h offline_file.h
  group cmsis-dap
    ../../../app/cmsis-dap/: DAP.c JTAG_DP.c SW_DP.c SWO.c usbd_user_hid.c
    ../../../app/: DAP_config.h
  group es-isp
    ../../../app/es-isp/: isp_prog_intf.c isp_prog_intf.h isp.h M620_ISP.c M620_ISP.h
  group es-debug
    ../../../app/es-debug/: hr7p169b_icd.c hr7p169b_icd.h debug_def.h
  group es-bootisp
    ../../../app/es-bootisp/: bootisp_prg_intf.c bootisp_target_flash.c bootisp_prg_intf.h bootisp_target_config.h bootisp_target_flash.h
  group swd-prg
    ../../../app/swd/: swd_prog_intf.c swd_target_flash.c swd_target_reset.c swd_host.c swd_flash_blob.h swd_flash_intf.h swd_host.h swd_target_config.h swd_target_reset.h swd_prog_intf.h
  group gui
    ../../../gui/: fonts.c oled.c link_menu.c message.c
  group iap
    ../../../iap/: update.c iap_flash_intf.c settings_rom.c
  group common
    ../../../common/: circ_buf.c circ_buf.h cortex_m.c cortex_m.h es_common.c es_common.h es_list.h es_types.h
  group CMSIS
    ../../../CMSIS/: system_MK22F12810.c system_MK22F12810.h MK22F12810.h MK22F12810_features.h fsl_device_registers.h core_cm4.h
  group drivers
    ../../../drivers/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_smc.c fsl_uart.c fsl_dspi.c fsl_flash.c
  group startup
    ../../../startup/: startup_MK22F12810.s
  group rtos
    ../../../rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../rtos/cm3/: HAL_CM3.c
  group fatfs
    ../../../middleware/FatFS/src/: ff.c diskio.c ffconf.h
    ../../../middleware/FatFS/src/option/: unicode.c
  group usb_driver
    ../../../middleware/RL-USB/: usb_config.c usbd_MK20D5.c usb_buf.h
  group usb
    ../../../middleware/RL-USB/usb/: usb_lib.c usbd_core.c
    ../../../middleware/RL-USB/usb/hid/: usbd_core_hid.c usbd_hid.c
    ../../../middleware/RL-USB/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../middleware/RL-USB/usb/cls/: usbd_cls.c usbd_core_cls.c
  group usb2uart
    ../../../app/usb2uart/: usbd_user_cdc_acm.c
  group doc
    ../doc/: 说明.txt 开发环境说明.txt
